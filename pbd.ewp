# IAR project pbd.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103K3 STM8S103K3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003
  ICCSTM8.CCIncludePath2: E:\QH\soft\ledctr; E:\QH\soft\ledctr\STM8S_StdPeriph_Driver\src; E:\QH\soft\ledctr\STM8S_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: pbd.hex
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: config.h i2c_ee.c i2c_ee.h isl1208.c isl1208.h main.c platform.c platform.h stm8s_conf.h stm8s_it.c stm8s_it.h
    STM8S_StdPeriph_Driver/src/: stm8s_tim4.c
  group driver
    STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_tim1.c stm8s_tim2.c stm8s_uart1.c
